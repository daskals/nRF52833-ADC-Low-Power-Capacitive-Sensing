<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>  <project>
    <path>$WS_DIR$\pca10100\blank\iar\adc_cap_pca10100.ewp</path>
  </project>  <batchBuild/>
</workspace>